Commit message: Enhance MoveIt config with full OMPL settings and dummy link

File: moveit_config/urdf/so100_ros.urdf (robot description, URDF)
Before this commit: robot so_arm100, 7 links, 6 joints
Links:
- added link world
Joints:
- added joint world_fixed: type fixed, parent world, child base
